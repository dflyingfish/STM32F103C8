<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM32F10x_MC Library.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\UserProject\STM32F10x_UserProject.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>workspace_rebuild_STM3210x-EVAL</name>
      <member>
        <project>STM32F10x_MC Library</project>
        <configuration>STM32F10x_SINGLE_DRIVE</configuration>
      </member>
      <member>
        <project>STM32F10x_UserProject</project>
        <configuration>STM32F10x</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


